options:
  parameters:
    generate_options: qt_gui
    id: GMSK_BAND
    output_language: python
    title: GMSK_BAND
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/konkapo/modulations_bandwidth_calc/hello
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
