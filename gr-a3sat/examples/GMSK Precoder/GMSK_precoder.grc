options:
  parameters:
    author: eleftheria
    copyright: A3SAT
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: GMSK Precoding
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: a3sat_gmsk_precoder_0
  id: a3sat_gmsk_precoder
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 2, 3, 4)
  states: {}

connections:
- [a3sat_gmsk_precoder_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', a3sat_gmsk_precoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']

metadata:
  file_format: 1
