options:
  parameters:
    author: SpaceDot
    description: OQPSK Modulation
    generate_options: hb
    id: OQPSK_mod
    output_language: python
    title: OQPSK Modulator
  states: {}

blocks:
- name: phase_bw
  id: variable
  parameters:
    value: 6.28/100
  states: {}
- name: alpha
  id: parameter
  parameters:
    label: alpha
    type: eng_float
    value: '0.5'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: delay
  id: parameter
  parameters:
    label: delay
    value: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: n_taps
  id: parameter
  parameters:
    label: Num Taps
    value: '11'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: n_taps
    samp_rate: sps
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: n_taps
    samp_rate: sps
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '32000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '4'
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    label: Symbol Rate
    type: intx
    value: '1'
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_delay_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repeat_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_repeat_0, '0', blocks_complex_to_real_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [pad_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_1, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
