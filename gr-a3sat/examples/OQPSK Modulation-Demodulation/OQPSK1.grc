options:
  parameters:
    author: SpaceDot
    generate_options: qt_gui
    id: OQPSK1
    output_language: python
    title: OQPSK_Mod_Demod
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.00'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.00001'
    step: '0.0001'
    stop: '1'
    value: '0.0001'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 6.28/100
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2 , 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.5, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 205*1000
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc: satnogs.crc.CRC32_C
    preamble: '0x55'
    preamble_len: '12'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    drop_invalid: 'True'
    frame_len: '255'
    preamble: '[0x55]*12'
    preamble_thrsh: '14'
    sync_thrsh: '5'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: OQPSK_mod_0
  id: OQPSK_mod
  parameters:
    alpha: '0.5'
    delay: '2'
    n_taps: '11'
    samp_rate: '32000'
    sps: '4'
    symbol_rate: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '1'
    msg: pmt.intern("TEST")
    std: '1'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps *8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.01'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.5'
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_1
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_pfb_clock_sync_xxx_1
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2* math.pi/100.0
    max_dev: '2'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: fff
  states: {}
- name: digital_pfb_clock_sync_xxx_1_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2* math.pi/100.0
    max_dev: '2'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: fff
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: 1024*4
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satnogs_ber_calculator_0
  id: satnogs_ber_calculator
  parameters:
    frame_size: '64'
    nframes: '10000'
    skip: '10'
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}

connections:
- [OQPSK_mod_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_complex_to_float_0, '0', digital_pfb_clock_sync_xxx_1, '0']
- [blocks_complex_to_float_0, '1', digital_pfb_clock_sync_xxx_1_0, '0']
- [blocks_complex_to_float_1, '0', blocks_delay_1, '0']
- [blocks_complex_to_float_1, '1', blocks_float_to_complex_2, '1']
- [blocks_delay_1, '0', blocks_float_to_complex_2, '0']
- [blocks_float_to_complex_0, '0', digital_cma_equalizer_cc_0, '0']
- [blocks_float_to_complex_2, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_float_to_complex_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_2, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_message_strobe_random_0, strobe, satnogs_ber_calculator_0, trigger]
- [blocks_pdu_to_tagged_stream_0, '0', OQPSK_mod_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_align_0, '0', channels_channel_model_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', satnogs_frame_decoder_0, '0']
- [channels_channel_model_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_1, '0']
- [digital_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_1, '0']
- [digital_diff_decoder_bb_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_1, '0', blocks_float_to_complex_0, '0']
- [digital_pfb_clock_sync_xxx_1_0, '0', blocks_float_to_complex_0, '1']
- [satnogs_ber_calculator_0, pdu, satnogs_frame_encoder_0, pdu]
- [satnogs_frame_decoder_0, out, satnogs_ber_calculator_0, received]
- [satnogs_frame_encoder_0, pdu, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
