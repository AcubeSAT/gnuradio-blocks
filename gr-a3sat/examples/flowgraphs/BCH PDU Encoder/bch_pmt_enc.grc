options:
  parameters:
    author: A3SAT
    copyright: A3SAT
    generate_options: qt_gui
    id: bch_pdu_enc
    output_language: python
    title: BCH PDU Encoder
  states: {}

blocks:
- name: idle_message_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: message_rate
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: a3sat_bch_pdu_encoder_0
  id: a3sat_bch_pdu_encoder
  parameters: {}
  states: {}
- name: satnogs_debug_msg_source_raw_0
  id: satnogs_debug_msg_source_raw
  parameters:
    delay: message_rate
    msg: '[51, 68, 85, 102]'
    repeat: 'False'
  states: {}
- name: satnogs_debug_msg_source_raw_1
  id: satnogs_debug_msg_source_raw
  parameters:
    delay: idle_message_rate
    msg: '[0]'
    repeat: 'True'
  states: {}
- name: satnogs_multi_format_msg_sink_0
  id: satnogs_multi_format_msg_sink
  parameters:
    filepath: ''
    format: '0'
    outstream: 'True'
    timestamp: 'False'
  states: {}

connections:
- [a3sat_bch_pdu_encoder_0, pdu, satnogs_multi_format_msg_sink_0, in]
- [satnogs_debug_msg_source_raw_0, msg, a3sat_bch_pdu_encoder_0, acquisition]
- [satnogs_debug_msg_source_raw_1, msg, a3sat_bch_pdu_encoder_0, idle]

metadata:
  file_format: 1
