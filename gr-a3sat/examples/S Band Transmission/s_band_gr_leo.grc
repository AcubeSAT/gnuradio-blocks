options:
  parameters:
    author: SpaceDot
    generate_options: qt_gui
    id: s_band_gr_leo
    output_language: python
    title: S band Testing
  states: {}

blocks:
- name: AUTH_GS
  id: variable_tracker
  parameters:
    comm_freq_rx: 2.425e9
    comm_freq_tx: 2.425e9
    gs_alt: '0.056'
    gs_lat: '22.959887'
    gs_lon: '40.627233'
    noise_figure: '0.4'
    noise_temp: '158'
    obs_end: '2023-07-03T15:32:00.000000Z'
    obs_start: '2023-07-03T15:25:00.000000Z'
    rx_antenna: Parabolic_Reflector_Patch
    rx_bw: 1.4e6
    satellite_info: AcubeSAT
    time_resolution_us: '1000'
    tx_antenna: Parabolic_Reflector_Patch
    tx_power_dbm: '30'
    value: fine
  states: {}
- name: AcubeSAT
  id: variable_satellite
  parameters:
    comm_freq_rx: 2.425e9
    comm_freq_tx: 2.425e9
    noise_figure: '0'
    noise_temp: '0'
    rx_antenna: Patch
    rx_bw: '10'
    tle_1: 1 69696U 16025E   23183.00000000  .00002000  00000-0  49111-4 0  6969
    tle_2: 2 69696  97.3759 191.5890 0001000 000.0000 000.0000 15.24261762696969
    tle_title: TLE_1
    tx_antenna: Patch
    tx_power_dbm: '30'
    value: '''ok'''
  states: {}
- name: Parabolic_Reflector_Patch
  id: variable_antenna
  parameters:
    aperture_efficiency: '70'
    beamwidth: '0'
    boom_length: '0'
    circumference: '0'
    diameter: '1'
    frequency: 2.425e9
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '2'
  states: {}
- name: Patch
  id: variable_antenna
  parameters:
    aperture_efficiency: '0'
    beamwidth: '108'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: 2.425e9
    gain: '4.13'
    lp: '0.5'
    pointing_error: '10'
    polarization: '1'
    rolloff_gain: '10'
    turn_spacing: '0'
    turns: '0'
    type: '3'
  states: {}
- name: S_Band_LEO_Model
  id: variable_leo_model_def
  parameters:
    atmo_gases_attenuation: '1'
    doppler_shift_enum: '7'
    enable_link_margin: 'True'
    fspl_attenuation_enum: '5'
    mode: '1'
    pointing_attenuation_enum: '6'
    precipitation_attenuation: '3'
    rainfall_rate: '25'
    surface_watervap_density: '7.5'
    temperature: '0'
    tracker: AUTH_GS
    value: '''fine'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: OQPSK_mod_0
  id: OQPSK_mod
  parameters:
    alpha: '0.5'
    delay: '0'
    n_taps: '11'
    samp_rate: samp_rate
    sps: '4'
    symbol_rate: '1'
  states: {}
- name: S_Band_Downlink
  id: leo_channel_model
  parameters:
    model: S_Band_LEO_Model
    noise_type: '1'
    sample_rate: samp_rate
    value: '''fine'''
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10000000'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    name: '"Transmitted Signal Bandwidth"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Received vs Transmitted Signal"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '100000'
    fc: '50000'
    fftsize: '4096'
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [OQPSK_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [OQPSK_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [S_Band_Downlink, '0', blocks_throttle_0, '0']
- [S_Band_Downlink, '0', qtgui_time_sink_x_0, '1']
- [S_Band_Downlink, csv, blocks_message_debug_0, print]
- [analog_random_source_x_0, '0', OQPSK_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', S_Band_Downlink, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
