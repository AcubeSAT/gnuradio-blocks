options:
  parameters:
    generate_options: qt_gui
    id: uhf_band_gr_leo
    output_language: python
    title: uhf_band_gr_leo
  states: {}

blocks:
- name: AUTH_GS
  id: variable_tracker
  parameters:
    comm_freq_rx: 436e6
    comm_freq_tx: 436e6
    gs_alt: '0.056'
    gs_lat: '22.959887'
    gs_lon: '40.627233'
    noise_figure: '0.4'
    noise_temp: '345'
    obs_end: '2023-07-03T15:32:00.000000Z'
    obs_start: '2023-07-03T15:25:00.000000Z'
    rx_antenna: Helical_Antenna
    rx_bw: '10000'
    satellite_info: AcubeSAT
    time_resolution_us: '1000'
    tx_antenna: Helical_Antenna
    tx_power_dbm: '30'
    value: fine
  states: {}
- name: AcubeSAT
  id: variable_satellite
  parameters:
    comm_freq_rx: 436e6
    comm_freq_tx: 436e6
    noise_figure: '1'
    noise_temp: '315'
    rx_antenna: Dipole_Antenna
    rx_bw: '10000'
    tle_1: 1 69696U 16025E   23183.00000000  .00002000  00000-0  49111-4 0  6969
    tle_2: 2 69696  97.3759 191.5890 0001000 000.0000 000.0000 15.24261762696969
    tle_title: TLE_1
    tx_antenna: Dipole_Antenna
    tx_power_dbm: '30'
    value: '''ok'''
  states: {}
- name: Dipole_Antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '0'
    beamwidth: '108'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: 436e6
    gain: '4.13'
    lp: '0.5'
    pointing_error: '80'
    polarization: '2'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '5'
  states: {}
- name: Helical_Antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '70'
    beamwidth: '0'
    boom_length: '0'
    circumference: '0.689'
    diameter: '1'
    frequency: 436e6
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0.1725'
    turns: '8'
    type: '1'
  states: {}
- name: UHF_Band_LEO_Model
  id: variable_leo_model_def
  parameters:
    atmo_gases_attenuation: '1'
    doppler_shift_enum: '7'
    enable_link_margin: 'True'
    fspl_attenuation_enum: '5'
    mode: '0'
    pointing_attenuation_enum: '6'
    precipitation_attenuation: '3'
    rainfall_rate: '25'
    surface_watervap_density: '7.5'
    temperature: '0'
    tracker: AUTH_GS
    value: '''fine'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: S_Band_Downlink
  id: leo_channel_model
  parameters:
    model: UHF_Band_LEO_Model
    noise_type: '1'
    sample_rate: samp_rate
    value: '''fine'''
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10000000'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_1
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: digital_gmsk_mod_2
  id: digital_gmsk_mod
  parameters:
    bt: '0.2'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color3: '"magenta"'
    fc: '0'
    fftsize: '1024'
    label1: GMSK  BT=0.2
    label2: GMSK  BT=0.35
    label3: GMSK  BT=0.5
    name: '"GMSK different BT comparison"'
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    grid: 'True'
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [S_Band_Downlink, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_0, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_1, '0']
- [analog_random_source_x_0, '0', digital_gmsk_mod_2, '0']
- [blocks_multiply_const_vxx_0, '0', S_Band_Downlink, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_gmsk_mod_1, '0', qtgui_freq_sink_x_0, '2']
- [digital_gmsk_mod_2, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
