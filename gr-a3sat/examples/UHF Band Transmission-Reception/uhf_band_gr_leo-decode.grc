options:
  parameters:
    generate_options: qt_gui
    id: uhf_band_gr_leo_decode
    output_language: python
    title: uhf_band_gr_leo_decode
  states: {}

blocks:
- name: AUTH_GS
  id: variable_tracker
  parameters:
    comm_freq_rx: 436e6
    comm_freq_tx: 436e6
    gs_alt: '0.056'
    gs_lat: '22.959887'
    gs_lon: '40.627233'
    noise_figure: '0.4'
    noise_temp: '245'
    obs_end: '2023-07-03T15:32:00.000000Z'
    obs_start: '2023-07-03T15:25:00.000000Z'
    rx_antenna: Helical_Antenna
    rx_bw: '20000'
    satellite_info: AcubeSAT
    time_resolution_us: 128*10000
    tx_antenna: Helical_Antenna
    tx_power_dbm: '41.14'
    value: fine
  states: {}
- name: AcubeSAT
  id: variable_satellite
  parameters:
    comm_freq_rx: 436e6
    comm_freq_tx: 436e6
    noise_figure: '.4'
    noise_temp: '315'
    rx_antenna: Turnstile_Antenna
    rx_bw: '20000'
    tle_1: 1 69696U 16025E   23183.00000000  .00002000  00000-0  49111-4 0  6969
    tle_2: 2 69696  97.3759 191.5890 0001000 000.0000 000.0000 15.24261762696969
    tle_title: TLE_1
    tx_antenna: Turnstile_Antenna
    tx_power_dbm: '30'
    value: '''ok'''
  states: {}
- name: Helical_Antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '70'
    beamwidth: '0'
    boom_length: '0'
    circumference: '0.689'
    diameter: '1'
    frequency: 436e6
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0.1725'
    turns: '8'
    type: '1'
  states: {}
- name: Turnstile_Antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '0'
    beamwidth: '72'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: 436e6
    gain: '2.64 '
    lp: '0.5'
    pointing_error: '10'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '3'
  states: {}
- name: UHF_Band_LEO_Model
  id: variable_leo_model_def
  parameters:
    atmo_gases_attenuation: '1'
    doppler_shift_enum: '0'
    enable_link_margin: 'True'
    fspl_attenuation_enum: '5'
    mode: '1'
    pointing_attenuation_enum: '6'
    precipitation_attenuation: '3'
    rainfall_rate: '25'
    surface_watervap_density: '7.5'
    temperature: '0'
    tracker: AUTH_GS
    value: '''fine'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: variable_ieee802_15_4_encoder_1
  id: variable_ieee802_15_4_encoder
  parameters:
    crc: satnogs.crc.CRC32_C
    preamble: '0x55'
    preamble_len: '7'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    drop_invalid: 'False'
    frame_len: '64'
    preamble: '[0x55]*7'
    preamble_thrsh: '14'
    sync_thrsh: '5'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: a3sat_bch_dec_1
  id: a3sat_bch_dec
  parameters: {}
  states: {}
- name: a3sat_bch_enc_1
  id: a3sat_bch_enc
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: cfo
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.35'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: leo_channel_model_1
  id: leo_channel_model
  parameters:
    model: UHF_Band_LEO_Model
    noise_type: '1'
    sample_rate: '2000000'
    value: '''fine'''
  states: {}
- name: satnogs_ber_calculator_0
  id: satnogs_ber_calculator
  parameters:
    frame_size: '64'
    nframes: '1000'
    skip: '10'
  states: {}
- name: satnogs_debug_msg_source_0
  id: satnogs_debug_msg_source
  parameters:
    delay: '0.01'
    msg: TEST
    repeat: 'True'
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_1
  states: {}
- name: snr
  id: parameter
  parameters:
    type: eng_float
    value: '12'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: samples per symbol
    type: intx
    value: '2'
  states: {}

connections:
- [a3sat_bch_dec_1, '0', satnogs_frame_decoder_0, '0']
- [a3sat_bch_enc_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_packed_to_unpacked_xx_1, '0', a3sat_bch_enc_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_throttle_2, '0']
- [blocks_throttle_2, '0', blocks_packed_to_unpacked_xx_1, '0']
- [digital_gmsk_demod_0, '0', a3sat_bch_dec_1, '0']
- [digital_gmsk_mod_0, '0', leo_channel_model_1, '0']
- [leo_channel_model_1, '0', digital_gmsk_demod_0, '0']
- [satnogs_ber_calculator_0, pdu, satnogs_frame_encoder_0, pdu]
- [satnogs_debug_msg_source_0, msg, satnogs_ber_calculator_0, trigger]
- [satnogs_frame_decoder_0, out, satnogs_ber_calculator_0, received]
- [satnogs_frame_encoder_0, pdu, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
